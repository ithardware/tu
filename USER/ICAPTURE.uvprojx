# Keil uVision project ICAPTURE.uvprojx, settings and files
target ICAPTURE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ICAPTURE +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe   --bin -o  ..\OBJ\ICAPTURE.bin ..\OBJ\ICAPTURE.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\STMFLASH;..\SLIS\CONTROL;..\SLIS\SAVE_DATA;..\SLIS\TIMER_IRQ;..\SLIS\HOSTIF;..\SLIS\SIM800C
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/KEY/: key.c
  group SLIS
    ../SLIS/TIMER_irq/: timer_irq.c
    ../SLIS/SAVE_DATA/: save_data.c
    ../SLIS/CONTROL/: control.c
    ../SLIS/HOSTIF/: hostif.c
    ../SLIS/SIM800C/: SIM800C.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_iwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group README
    ../: README.TXT
